Commit message: update urdf

File: src/pkg_urdf/urdf/example_joint.urdf (robot description, URDF)
Before this commit: robot robot_link, 1 links, 0 joints
Links:
- added link world
Joints:
- added joint world_to_link1: type fixed, parent world, child link1, origin xyz=0 0 0.5 rpy=0 0 0
